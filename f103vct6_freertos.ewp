# IAR project f103vct6_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VC ST STM32F103VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: CMSIS\system; FWLIB\inc; User\inc; CMSIS; board_mcu\inc; lora; STM32_Cryptographic_Library; STM32_Cryptographic_Library\inc; User\inc; board_mcu; User\src; freertos; freertos\inc; freertos\portable; easylogger\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: freertos
  OBJCOPY.OOCOutputFile: f103vct6_freertos.bin
  ILINK.IlinkOutputFile: HN_LoRa_CCU.out
  ILINK.IlinkIcfFile: E:\桌面\FreeRTOS\f103vct6_freertos\CMSIS\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board_mcu
    board_mcu/src/: gpio.c led_watchdog.c my_string.c rs485.c timer.c uart.c
  group CMSIS
    CMSIS/: stm32f10x_it.c
  group CMSIS/startup
    CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS/system
    CMSIS/system/: system_stm32f10x.c
  group doc
    doc/: Readme.txt
  group easylogger
    easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    easylogger/port/: elog_port.c
  group freertos
    freertos/: FreeRTOSConfig.h
    freertos/portable/: portasm.s
  group freertos/portable
    freertos/portable/MemMang/: heap_4.c
    freertos/portable/: port.c
  group freertos/src
    freertos/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FWLIB
    FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    User/src/: main.c mytask.c
