<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\f103vct6_freertos.ewp</path>
    </project>
    <batchBuild />
</workspace>
